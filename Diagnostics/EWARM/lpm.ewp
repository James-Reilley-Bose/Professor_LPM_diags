# IAR project lpm.ewp, settings and files
configuration Professor (ARM, debug)
  General.OGChipSelectEditMenu: STM32F205VG ST STM32F205VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDiagSuppress: Pa050, Pa039, Pe550
  ICCARM.IExtraOptions: --enum_is_int; --no_path_in_file_macros
  ICCARM.PreInclude: ..\Product\Configuration\Professor\product_predefine.h
  ICCARM.CCIncludePath2: ..\; ..\Product\Diags; ..\A4VCommon; ..\A4VCommon\Accessories; ..\A4VCommon\Remote; ..\A4VCommon\Uei; ..\A4VCommon\Update; ..\A4VCommon\WiredID; ..\A4VCommon\WiredID\Common; ..\A4VCommon\WiredID\Console; ..\A4VCommon\WiredID\Utilities; ..\A4VCommon\WirelessAudio; ..\A4VCommon\WirelessAudio\common; ..\A4VCommon\WirelessAudio\CU; ..\A4VCommon\WirelessAudio\MU; ..\A4VCommon\WirelessAudio\Utilities; ..\Core; ..\Core\Drivers\Bose; ..\Core\Drivers\Bose\Common; ..\Core\Drivers\Bose\External\; ..\Core\Drivers\Bose\External\CC2500; ..\Core\Drivers\Bose\External\SPIFlash; ..\Core\Drivers\Bose\Internal; ..\Core\Drivers\Bose\Internal\ADC; ..\Core\Drivers\Bose\Internal\DMA_Manager; ..\Core\Drivers\Bose\Internal\I2C; ..\Core\Drivers\Bose\Internal\InternalFlash; ..\Core\Drivers\Bose\Internal\IR; ..\Core\Drivers\Bose\Internal\SPI; ..\Core\Drivers\Bose\Internal\UART; ..\Core\Drivers\ST\STM32F1xx\CoreSupport; ..\Core\Drivers\ST\STM32F1xx\DeviceSupport; ..\Core\Drivers\ST\STM32F1xx\DeviceSupport\startup; ..\Core\Drivers\ST\STM32F1xx\STM32F10x_StdPeriph_Driver; ..\Core\Drivers\ST\STM32F1xx\STM32F10x_StdPeriph_Driver\inc; ..\Core\Drivers\ST\STM32F1xx\STM32F10x_StdPeriph_Driver\src; ..\Core\Drivers\ST\STM32F2xx\CoreSupport; ..\Core\Drivers\ST\STM32F2xx\DeviceSupport; ..\Core\Drivers\ST\STM32F2xx\DeviceSupport\iar; ..\Core\Drivers\ST\STM32F2xx\STM32_USB_Device_Library\Class\cdc\inc; ..\Core\Drivers\ST\STM32F2xx\STM32_USB_Device_Library\Core\inc; ..\Core\Drivers\ST\STM32F2xx\STM32_USB_OTG_Driver\inc; ..\Core\Drivers\ST\STM32F2xx\STM32F2xx_StdPeriph_Driver; ..\Core\Drivers\ST\STM32F2xx\STM32F2xx_StdPeriph_Driver\inc; ..\Core\Drivers\ST\STM32F2xx\STM32F2xx_StdPeriph_Driver\src; ..\Core\Drivers\ST\STM32F2xx\USB_VCP_Logger\inc; ..\Core\Middleware\Bose\Common; ..\Core\Middleware\Bose\Common\PWMTimer; ..\Core\Middleware\Bose\Configuration; ..\Core\Middleware\Bose\DeviceModel; ..\Core\Middleware\Bose\IPC; ..\Core\Middleware\Bose\IPC\Serial; ..\Core\Middleware\Bose\IPC\Serial\I2C; ..\Core\Middleware\Bose\IPC\Serial\SPI; ..\Core\Middleware\Bose\IPC\Serial\UART; ..\Core\Middleware\Bose\IPC\Support; ..\Core\Middleware\Bose\Keys; ..\Core\Middleware\Bose\LightBarCapSense; ..\Core\Middleware\Bose\LightSensor; ..\Core\Middleware\Bose\Logging; ..\Core\Middleware\Bose\Logging\TBLSerial; ..\Core\Middleware\Bose\NVRam; ..\Core\Middleware\Bose\NVRam\include; ..\Core\Middleware\Bose\NVRam\source; ..\Core\Middleware\Bose\Power; ..\Core\Middleware\Bose\SourceChange; ..\Core\Middleware\Bose\SystemState; ..\Core\Middleware\Bose\SystemState\States; ..\Core\Middleware\Bose\Tap; ..\Core\Middleware\Bose\Tap\Listener; ..\Core\Middleware\Bose\Tap\Parser; ..\Core\Middleware\Bose\UI; ..\Core\Middleware\Bose\Update; ..\Core\Middleware\ThirdParty\Compression\Heatshrink; ..\Core\RTOS\FreeRTOS; ..\Core\RTOS\FreeRTOS\CortexM3_Port; ..\Core\RTOS\FreeRTOS\include; ..\Core\Shared; ..\Product; ..\Product\Accessories; ..\Product\CEC; ..\Product\Configuration; ..\Product\Configuration\Professor; ..\Product\DeviceModel; ..\Product\EDID; ..\Product\Keys; ..\Product\NVRam; ..\Product\Power; ..\Product\SII9437; ..\Product\SiliconImage; ..\Product\SiliconImage\application; ..\Product\SiliconImage\application\Sil9437; ..\Product\SiliconImage\application\SiI9437\platform_nuc123_coos; ..\Product\SiliconImage\driver\; ..\Product\SiliconImage\driver\internal; ..\Product\SiliconImage\driver\internal\assert; ..\Product\SiliconImage\driver\internal\cra; ..\Product\SiliconImage\driver\internal\log; ..\Product\SiliconImage\driver\internal\malloc; ..\Product\SiliconImage\driver\internal\obj; ..\Product\SiliconImage\driver\internal\pipe; ..\Product\SiliconImage\driver\internal\seq; ..\Product\SiliconImage\driver\internal\time; ..\Product\SiliconImage\driver\sii9437; ..\Product\SiliconImage\platform; ..\Product\SiliconImage\platform\nuc123_coos; ..\Product\SystemStates; ..\Product\Tap; ..\Product\Tasks; ..\Product\Timers; ..\Product\Update; ..\Product\UI; ..\Shared; ..\Core\Middleware\Bose\LightBarCapSense; ..\Core\Drivers\Bose\External\PSoC4
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: USING_FREE_RTOS; NEW_INTERRUPT_SCHEME
  AARM.AUserIncludes: ..\Core\Middleware\Bose\Common; ..\Product\Configuration; ..\Product\Configuration\Professor
  OBJCOPY.OOCOutputFile: lpm.bin
  prebuild: prebuild.bat $PROJ_DIR$
  postbuild: ielftool.exe --ihex "$TARGET_PATH$" "$TARGET_BPATH$.hex"
  ILINK.IlinkOutputFile: lpm.out
  ILINK.IlinkIcfFile: icf\PROFESSOR.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Professor_DP2 (ARM, debug)
  as the first configuration, except:
  ICCARM.CCIncludePath2: ..\; ..\Product\Diags; ..\A4VCommon; ..\A4VCommon\Accessories; ..\A4VCommon\Remote; ..\A4VCommon\Uei; ..\A4VCommon\Update; ..\A4VCommon\WiredID; ..\A4VCommon\WiredID\Common; ..\A4VCommon\WiredID\Console; ..\A4VCommon\WiredID\Utilities; ..\A4VCommon\WirelessAudio; ..\A4VCommon\WirelessAudio\common; ..\A4VCommon\WirelessAudio\CU; ..\A4VCommon\WirelessAudio\MU; ..\A4VCommon\WirelessAudio\Utilities; ..\Core; ..\Core\Drivers\Bose; ..\Core\Drivers\Bose\Common; ..\Core\Drivers\Bose\External\; ..\Core\Drivers\Bose\External\CC2500; ..\Core\Drivers\Bose\External\SPIFlash; ..\Core\Drivers\Bose\Internal; ..\Core\Drivers\Bose\Internal\ADC; ..\Core\Drivers\Bose\Internal\DMA_Manager; ..\Core\Drivers\Bose\Internal\I2C; ..\Core\Drivers\Bose\Internal\InternalFlash; ..\Core\Drivers\Bose\Internal\IR; ..\Core\Drivers\Bose\Internal\SPI; ..\Core\Drivers\Bose\Internal\UART; ..\Core\Drivers\ST\STM32F1xx\CoreSupport; ..\Core\Drivers\ST\STM32F1xx\DeviceSupport; ..\Core\Drivers\ST\STM32F1xx\DeviceSupport\startup; ..\Core\Drivers\ST\STM32F1xx\STM32F10x_StdPeriph_Driver; ..\Core\Drivers\ST\STM32F1xx\STM32F10x_StdPeriph_Driver\inc; ..\Core\Drivers\ST\STM32F1xx\STM32F10x_StdPeriph_Driver\src; ..\Core\Drivers\ST\STM32F2xx\CoreSupport; ..\Core\Drivers\ST\STM32F2xx\DeviceSupport; ..\Core\Drivers\ST\STM32F2xx\DeviceSupport\iar; ..\Core\Drivers\ST\STM32F2xx\STM32_USB_Device_Library\Class\cdc\inc; ..\Core\Drivers\ST\STM32F2xx\STM32_USB_Device_Library\Core\inc; ..\Core\Drivers\ST\STM32F2xx\STM32_USB_OTG_Driver\inc; ..\Core\Drivers\ST\STM32F2xx\STM32F2xx_StdPeriph_Driver; ..\Core\Drivers\ST\STM32F2xx\STM32F2xx_StdPeriph_Driver\inc; ..\Core\Drivers\ST\STM32F2xx\STM32F2xx_StdPeriph_Driver\src; ..\Core\Drivers\ST\STM32F2xx\USB_VCP_Logger\inc; ..\Core\Middleware\Bose\Common; ..\Core\Middleware\Bose\Common\PWMTimer; ..\Core\Middleware\Bose\Configuration; ..\Core\Middleware\Bose\DeviceModel; ..\Core\Middleware\Bose\IPC; ..\Core\Middleware\Bose\IPC\Serial; ..\Core\Middleware\Bose\IPC\Serial\I2C; ..\Core\Middleware\Bose\IPC\Serial\SPI; ..\Core\Middleware\Bose\IPC\Serial\UART; ..\Core\Middleware\Bose\IPC\Support; ..\Core\Middleware\Bose\Keys; ..\Core\Middleware\Bose\LightBarCapSense; ..\Core\Middleware\Bose\LightSensor; ..\Core\Middleware\Bose\Logging; ..\Core\Middleware\Bose\Logging\TBLSerial; ..\Core\Middleware\Bose\NVRam; ..\Core\Middleware\Bose\NVRam\include; ..\Core\Middleware\Bose\NVRam\source; ..\Core\Middleware\Bose\Power; ..\Core\Middleware\Bose\SourceChange; ..\Core\Middleware\Bose\SystemState; ..\Core\Middleware\Bose\SystemState\States; ..\Core\Middleware\Bose\Tap; ..\Core\Middleware\Bose\Tap\Listener; ..\Core\Middleware\Bose\Tap\Parser; ..\Core\Middleware\Bose\UI; ..\Core\Middleware\Bose\Update; ..\Core\Middleware\ThirdParty\Compression\Heatshrink; ..\Core\RTOS\FreeRTOS; ..\Core\RTOS\FreeRTOS\CortexM3_Port; ..\Core\RTOS\FreeRTOS\include; ..\Core\Shared; ..\Product; ..\Product\Accessories; ..\Product\CEC; ..\Product\Configuration; ..\Product\Configuration\Professor_DP2; ..\Product\DeviceModel; ..\Product\EDID; ..\Product\Keys; ..\Product\NVRam; ..\Product\Power; ..\Product\SII9437; ..\Product\SiliconImage; ..\Product\SiliconImage\application; ..\Product\SiliconImage\application\Sil9437; ..\Product\SiliconImage\application\SiI9437\platform_nuc123_coos; ..\Product\SiliconImage\driver\; ..\Product\SiliconImage\driver\internal; ..\Product\SiliconImage\driver\internal\assert; ..\Product\SiliconImage\driver\internal\cra; ..\Product\SiliconImage\driver\internal\log; ..\Product\SiliconImage\driver\internal\malloc; ..\Product\SiliconImage\driver\internal\obj; ..\Product\SiliconImage\driver\internal\pipe; ..\Product\SiliconImage\driver\internal\seq; ..\Product\SiliconImage\driver\internal\time; ..\Product\SiliconImage\driver\sii9437; ..\Product\SiliconImage\platform; ..\Product\SiliconImage\platform\nuc123_coos; ..\Product\SystemStates; ..\Product\Tap; ..\Product\Tasks; ..\Product\Timers; ..\Product\Update; ..\Product\UI; ..\Shared; ..\Core\Middleware\Bose\LightBarCapSense; ..\Core\Drivers\Bose\External\PSoC4
  group A4VCommon/Accessories
    ../A4VCommon/Accessories/: AccessoryManager.c AccessoryManager.h WiredBass.c WiredBass.h
  group A4VCommon/Remote
    ../A4VCommon/Remote/: RemoteDefs.h RemoteDriver.c RemoteDriver.h RemoteNames.c RemoteNames.h RemoteRx.c RemoteRx.h RemoteSPI.c RemoteSPI.h RemoteState.c RemoteState.h RemoteTap.c RemoteTap.h RemoteTask.c RemoteTask.h RemoteTx.c RemoteTx.h RemoteUpdate.c RemoteUpdate.h RemoteUtility.c RemoteUtility.h
  group A4VCommon/Uei
    ../A4VCommon/Uei/: UEI_KeyIndex.h UEIConfig.h UEIDefinitions.h UEISerial.c UEISerial.h UEIServices.c UEIServices.h UEITask.c UEITask.h
  group A4VCommon/Update
    ../A4VCommon/Update/: UpdateModuleBleRadio.c UpdateModuleBleRadio.h UpdateModuleDsp.c UpdateModuleDsp.h UpdateModuleF0.c UpdateModuleF0.h UpdateModuleRadio.c UpdateModuleRadio.h UpdateModuleSpeakers.c UpdateModuleSpeakers.h
  group A4VCommon/WiredID
    ../A4VCommon/WiredID/: WiredIDTask.c WiredIDTask.h WiredIDVariant.h
  group A4VCommon/WiredID/Common
    ../A4VCommon/WiredID/Common/: WiredIDInterrupt.c WiredIDInterrupt.h
  group A4VCommon/WiredID/Console
    ../A4VCommon/WiredID/Console/: WiredIDConsoleBase.c WiredIDConsoleBase.h WiredIDConsoleBassConnected.c WiredIDConsoleBassConnected.h WiredIDConsoleConfirming.c WiredIDConsoleConfirming.h WiredIDConsoleDisabled.c WiredIDConsoleDisabled.h WiredIDConsoleStartScan.c WiredIDConsoleStartScan.h WiredIDConsoleTask.c WiredIDConsoleTask.h WiredIDConsoleWaitRetry.c WiredIDConsoleWaitRetry.h WiredIDConsoleWFFScan.c WiredIDConsoleWFFScan.h WiredIDConsoleWFRScan.c WiredIDConsoleWFRScan.h
  group A4VCommon/WiredID/Utilities
    ../A4VCommon/WiredID/Utilities/: WiredIDConsoleUtilities.c WiredIDUtilities.c WiredIDUtilities.h WiredIDVariantUtilities.h
  group A4VCommon/WirelessAudio
    ../A4VCommon/WirelessAudio/: WirelessAudioAPI.c WirelessAudioAPI.h WirelessAudioTask.c WirelessAudioTask.h WirelessAudioVariant.h
  group A4VCommon/WirelessAudio/common
    ../A4VCommon/WirelessAudio/common/: darr_prog_new_qual_03.01.25_8437.h WirelessAudioData.h WirelessAudioI2C.c WirelessAudioI2C.h WirelessAudioISR.c WirelessAudioISR.h WirelessAudioNV.h WirelessAudioUpdate.c WirelessAudioUpdate.h WirelessAudioUpdateTransfer.h
  group A4VCommon/WirelessAudio/CU
    ../A4VCommon/WirelessAudio/CU/: WirelessAudioCUBase.c WirelessAudioCUBase.h WirelessAudioCUOff.c WirelessAudioCUOff.h WirelessAudioCUOn.c WirelessAudioCUOn.h WirelessAudioCUPairing.c WirelessAudioCUPairing.h WirelessAudioCUTask.c WirelessAudioCUTask.h WirelessAudioCUUpdate.c WirelessAudioCUUpdate.h WirelessAudioCUUpdTx.c WirelessAudioCUUpdTxUtil.c
  group A4VCommon/WirelessAudio/Utilities
    ../A4VCommon/WirelessAudio/Utilities/: WirelessAudioCUUtilities.c WirelessAudioUtilities.c WirelessAudioUtilities.h WirelessAudioVariantUtilities.h
  group Core/Drivers/Bose/Common
    ../Core/Drivers/Bose/Common/: driverLibCommon.c driverLibCommon.h
  group Core/Drivers/Bose/External/CC2500
    ../Core/Drivers/Bose/External/CC2500/: CC2500_driver.c CC2500_driver.h cc2500_platform.c cc2500_platform.h regs_chipcon.h RFTimer.c RFTimer.h
  group Core/Drivers/Bose/External/PSoC
    ../Core/Drivers/Bose/External/PSoC4/: cybtldr_api.c cybtldr_api.h cybtldr_command.c cybtldr_command.h cybtldr_parse.c cybtldr_parse.h cybtldr_utils.h psocbootloader.c psocbootloader.h
  group Core/Drivers/Bose/External/SPIFlash
    ../Core/Drivers/Bose/External/SPIFlash/: mmsw_byte_ordering.h mmsw_util.h nvram.c nvram.h nvram_device.c nvram_device.h nvram_platform.c nvram_platform.h
  group Core/Drivers/Bose/Internal/ADC
    ../Core/Drivers/Bose/Internal/ADC/: adc.c adc.h
  group Core/Drivers/Bose/Internal/DMA
    ../Core/Drivers/Bose/Internal/DMA_Manager/: DmaManager.c DmaManager.h DmaManagerInternal.h
  group Core/Drivers/Bose/Internal/I2C
    ../Core/Drivers/Bose/Internal/I2C/: i2cBusDriver.h i2cMaster_API.c i2cMaster_API.h
  group Core/Drivers/Bose/Internal/InternalFlash
    ../Core/Drivers/Bose/Internal/InternalFlash/: internalFlash.c internalFlash.h internalFlash_STM32F205RE.h internalFlash_STM32F205VG.h internalFlashAPI.c internalFlashAPI.h
  group Core/Drivers/Bose/Internal/IR
    ../Core/Drivers/Bose/Internal/IR/: ir.c ir.h RivieraLpm_CompressedKeys.c RivieraLpm_CompressedKeys.h
  group Core/Drivers/Bose/Internal/SPI
    ../Core/Drivers/Bose/Internal/SPI/: SpiBus_API.c SpiBus_API.h SpiBusDriver.h SpiSlave.c SpiSlave.h
  group Core/Drivers/Bose/Internal/UART
    ../Core/Drivers/Bose/Internal/UART/: BoseUSART_API.c BoseUSART_API.h
  group Core/Drivers/ST/CoreSupport
    ../Core/Drivers/ST/STM32F2xx/CoreSupport/: core_cm3.c core_cm3.h cortexm3_macro.s exception_handle.s
  group Core/Drivers/ST/DeviceSupport
    ../Core/Drivers/ST/STM32F2xx/DeviceSupport/: stm32f2xx.h system_stm32f2xx.c system_stm32f2xx.h
  group Core/Drivers/ST/DeviceSupport/iar
    ../Core/Drivers/ST/STM32F2xx/DeviceSupport/iar/: stm32f2xx_conf.h stm32f2xx_interrupts.c stm32f2xx_interrupts.h stm32f2xx_vectortable.c
  group Core/Drivers/ST/STM32_USB_Device_Library/Class/cdc/src
    ../Core/Drivers/ST/STM32F2xx/STM32_USB_Device_Library/Class/cdc/src/: usbd_cdc_core.c
  group Core/Drivers/ST/STM32_USB_Device_Library/Core/src
    ../Core/Drivers/ST/STM32F2xx/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
  group Core/Drivers/ST/STM32_USB_OTG_Driver/src
    ../Core/Drivers/ST/STM32F2xx/STM32_USB_OTG_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c
  group Core/Drivers/ST/STM32F2xx_StdPeriph_Driver/inc
    ../Core/Drivers/ST/STM32F2xx/STM32F2xx_StdPeriph_Driver/inc/: misc.h stm32f2xx_adc.h stm32f2xx_can.h stm32f2xx_crc.h stm32f2xx_cryp.h stm32f2xx_dac.h stm32f2xx_dbgmcu.h stm32f2xx_dcmi.h stm32f2xx_dma.h stm32f2xx_exti.h stm32f2xx_flash.h stm32f2xx_fsmc.h stm32f2xx_gpio.h stm32f2xx_hash.h stm32f2xx_i2c.h stm32f2xx_ip_dbg.h stm32f2xx_iwdg.h stm32f2xx_pwr.h stm32f2xx_rcc.h stm32f2xx_rng.h stm32f2xx_rtc.h stm32f2xx_sdio.h stm32f2xx_spi.h stm32f2xx_syscfg.h stm32f2xx_tim.h stm32f2xx_usart.h stm32f2xx_wwdg.h
  group Core/Drivers/ST/STM32F2xx_StdPeriph_Driver/src
    ../Core/Drivers/ST/STM32F2xx/STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_adc.c stm32f2xx_can.c stm32f2xx_crc.c stm32f2xx_cryp.c stm32f2xx_cryp_aes.c stm32f2xx_cryp_des.c stm32f2xx_cryp_tdes.c stm32f2xx_dac.c stm32f2xx_dbgmcu.c stm32f2xx_dcmi.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_fsmc.c stm32f2xx_gpio.c stm32f2xx_hash.c stm32f2xx_hash_md5.c stm32f2xx_hash_sha1.c stm32f2xx_i2c.c stm32f2xx_ip_dbg.c stm32f2xx_iwdg.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_rng.c stm32f2xx_rtc.c stm32f2xx_sdio.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c stm32f2xx_wwdg.c
  group Core/Drivers/ST/USB_VCP_Logger/inc
    ../Core/Drivers/ST/STM32F2xx/USB_VCP_Logger/inc/: usb_conf.h usbd_cdc_logger.h usbd_conf.h usbd_desc.h
  group Core/Drivers/ST/USB_VCP_Logger/src
    ../Core/Drivers/ST/STM32F2xx/USB_VCP_Logger/src/: usb_bsp.c usbd_cdc_logger.c usbd_desc.c
  group Core/Middleware/Bose/Common
    ../Core/Middleware/Bose/Common/: Assert.h BCRC.c BCRC.h bitband.h BMutex.c BMutex.h boselinkmessages.h buffermanager.c buffermanager.h defs.h EventBlocking.c EventBlocking.h EventDefinitions.c EventDefinitions.h exception_handle.h genTimer.c genTimer.h gpio_mapping.c gpio_mapping.h HexParse.c HexParse.h HwMacros.h instrument.c instrument.h interrupt.c interrupt.h lastGasp.c lastGasp.h LinkedList.c LinkedList.h main.c mpu.c mpu.h platform_settings.h project.h QueueManager.c QueueManager.h stringbuffer.c stringbuffer.h SystemAnalysis.c SystemAnalysis.h SystemAnalysisDefines.h SystemCoreReboot.c SystemMessages.h TaskDefs.c TaskDefs.h TaskManager.c TaskManager.h TimerIDs.h TIMx.h unwind.c unwind.h version.h viewNotify.c viewNotify.h watchdog.c watchdog.h
  group Core/Middleware/Bose/Common/PWMTimer
    ../Core/Middleware/Bose/Common/PWMTimer/: GingerPWMTimerConfig.c MaxwellPWMTimerConfig.c PWMTimer.c PWMTimer.h PWMTimerConfig.h SkipperPWMTimerConfig.c
  group Core/Middleware/Bose/Configuration
    ../Core/Middleware/Bose/Configuration/: configuresystem.h
  group Core/Middleware/Bose/DeviceModel
    ../Core/Middleware/Bose/DeviceModel/: DeviceInterface.h DeviceModelTask.c DeviceModelTask.h
  group Core/Middleware/Bose/IPC
    ../Core/Middleware/Bose/IPC/: IPCBulk.c IPCBulk.h IpcInterface.c IpcInterface.h IpcPassThrough.c IpcPassThrough.h IpcPlatformConfig.h IpcProtocolLpm.c IpcProtocolLpm.h IPCRouterTask.c IPCRouterTask.h IpcVariant.h
  group Core/Middleware/Bose/IPC/Serial/I2C
    ../Core/Middleware/Bose/IPC/Serial/I2C/: IpcI2CRxTxTask.c IpcI2CRxTxTask.h
  group Core/Middleware/Bose/IPC/Serial/SPI
    ../Core/Middleware/Bose/IPC/Serial/SPI/: SpiIpcTask.c SpiIpcTask.h
  group Core/Middleware/Bose/IPC/Serial/UART
    ../Core/Middleware/Bose/IPC/Serial/UART/: IpcRx.c IpcRx.h IpcTx.c IpcTx.h IpcTxTask.c IpcTxTask.h IpcUart.c IpcUart.h
  group Core/Middleware/Bose/IPC/Support
    ../Core/Middleware/Bose/IPC/Support/: IpcDsp.c IpcDsp.h IpcKeys.c IpcKeys.h IpcStatus.c IpcStatus.h IpcTest.c IpcTest.h
  group Core/Middleware/Bose/Keys
    ../Core/Middleware/Bose/Keys/: ConsoleKeys.c ConsoleKeys.h KeyData.h KeyHandler.c KeyHandler.h KeyHandlerTask.c KeyHandlerTask.h KeyTimings.h KeyValues.c
  group Core/Middleware/Bose/LightBarCapSense
    ../Core/Middleware/Bose/LightBarCapSense/: LightBarAnimationDB.c LightBarAnimationDB.h LightBarCapSenseTap.c LightBarCapSenseTask.c LightBarCapSenseTask.h
  group Core/Middleware/Bose/LightSensor
    ../Core/Middleware/Bose/LightSensor/: LightSensorTask.c LightSensorTask.h
  group Core/Middleware/Bose/Logging
    ../Core/Middleware/Bose/Logging/: ipcstore.c ipcstore.h LoggerTask.c LoggerTask.h logimpl.c nvstore.c nvstore.h ringbufferstore.c ringbufferstore.h rottenlog.c rottenlog.h tapstore.c tapstore.h
  group Core/Middleware/Bose/Logging/TBLSerial
    ../Core/Middleware/Bose/Logging/TBLSerial/: TBLSerial.c TBLSerial.h
  group Core/Middleware/Bose/NVRam
    ../Core/Middleware/Bose/NVRam/: nv.h nv_internal_params.c nv_internal_params.h nv_mfg.c nv_mfg.h nv_mfg_struct.h nv_system.c nv_system.h nv_system_struct.h NVTask.c NVTask.h
  group Core/Middleware/Bose/Power
    ../Core/Middleware/Bose/Power/: PowerRiviera.c PowerRiviera.h PowerRiviera_New.c PowerTask.c PowerTask.h
  group Core/Middleware/Bose/SourceChange
    ../Core/Middleware/Bose/SourceChange/: SourceChangeTask.c SourceChangeTask.h sourceInterface.h SourceRecipe.h unifySourceList.c unifySourceList.h
  group Core/Middleware/Bose/SystemState
    ../Core/Middleware/Bose/SystemState/: SystemStateBase.c SystemStateBase.h SystemStateTask.c SystemStateTask.h
  group Core/Middleware/Bose/SystemState/States
    ../Core/Middleware/Bose/SystemState/States/: SystemStateBooting.c SystemStateBooting.h SystemStateFactoryDefault.c SystemStateFactoryDefault.h SystemStateLowPower.c SystemStateLowPower.h SystemStateNormal.c SystemStateNormal.h SystemStateOff.c SystemStateOff.h SystemStateRecovery.c SystemStateRecovery.h SystemStateShutdown.c SystemStateShutdown.h SystemStateUpdate.c SystemStateUpdate.h
  group Core/Middleware/Bose/Tap
    ../Core/Middleware/Bose/Tap/: ascii.h
  group Core/Middleware/Bose/Tap/Listener
    ../Core/Middleware/Bose/Tap/Listener/: serialTapListener.c serialTapListener.h TapListenerAPI.c TapListenerAPI.h
  group Core/Middleware/Bose/Tap/Parser
    ../Core/Middleware/Bose/Tap/Parser/: etap.c etap.h etapAssert.c etapAssert.h etapcoms.c etapcoms.h etapFlash.c etapFlash.h etapGpio.c etapGpio.h etapHeap.c etapHeap.h etapI2C.c etapI2C.h etapInternalFlash.c etapInternalFlash.h etapIpc.c etapIpc.h etapKeys.c etapKeys.h etapLBCS.h etapLog.c etapLog.h etapNV.c etapNV.h etapPassthrough.c etapPassthrough.h etapPower.c etapPower.h etapSpi.c etapSpi.h etapTasks.c etapTasks.h etapuei.c etapuei.h etapUpdate.c etapUpdate.h etapWirelessAudio.c etapWirelessAudio.h SystemEventsTAP.c SystemEventsTAP.h TAP_API.h TapParserAPI.c TapParserAPI.h
  group Core/Middleware/Bose/UI
    ../Core/Middleware/Bose/UI/: systemBehaviors.c systemBehaviors.h UITask.c UITask.h
  group Core/Middleware/Bose/Update
    ../Core/Middleware/Bose/Update/: UpdateManagerBlob.c UpdateManagerBlob.h UpdateManagerStateDefinitions.c UpdateManagerStateDefinitions.h UpdateManagerTask.c UpdateManagerTask.h UpdateModuleAuthenticate.c UpdateModuleAuthenticate.h UpdateModuleBase.c UpdateModuleBase.h UpdateModuleDownloading.c UpdateModuleDownloading.h UpdateModuleInactive.c UpdateModuleInactive.h UpdateModuleMicro.c UpdateModuleMicro.h UpdateModuleWaitDownload.c UpdateModuleWaitDownload.h UpdateModuleWaitExtPeriph.c UpdateModuleWaitExtPeriph.h UpdateModuleWaitInstall.c UpdateModuleWaitInstall.h UpdateTypes.h
  group Core/RTOS/FreeRTOS
    ../Core/RTOS/FreeRTOS/: croutine.c event_groups.c heap_4.c list.c queue.c tasks.c timers.c
  group Core/RTOS/FreeRTOS/CortexM3_Port
    ../Core/RTOS/FreeRTOS/CortexM3_Port/: port.c portasm.s portmacro.h
  group Core/RTOS/FreeRTOS/include
    ../Core/RTOS/FreeRTOS/include/: croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h
  group Product/Accessories
    ../Product/Accessories/: AccessoryVariant.c AccessoryVariant.h
  group Product/CEC
    ../Product/CEC/: cec.h CEC_ControlInterface.c CEC_ControlInterface.h CEC_KeyIndex.h CEC_Utilities.c CEC_Utilities.h CECTask.c CECTask.h
  group Product/Configuration
    ../Product/Configuration/: FreeRTOSConfig.h version.h
  group Product/Configuration/Professor
    ../Product/Configuration/Professor/: nvram_platform_config.h product_config.c product_config.h product_ext_flash_map.h product_macros.h product_memory_map.h product_pin_mapping.h product_predefine.h
  group Product/Configuration/Professor_DP2
    ../Product/Configuration/Professor_DP2/: nvram_platform_config.h product_config.c product_config.h product_ext_flash_map.h product_macros.h product_memory_map.h product_pin_mapping.h product_predefine.h
  group Product/DeviceModel
    ../Product/DeviceModel/: DeviceInterfaceVariant.c DeviceInterfaceVariant.h DeviceModel_DSP.c DeviceModel_DSP.h DeviceModel_DSP_Standin.c DeviceModel_DSP_Standin.h DeviceStatusFieldDefs.h
  group Product/Diags
    ../Product/Diags/: ascii.h diag_cec.c diag_cec.h Diag_i2c_test.c Diag_i2c_test.h DiagData.h DiagRivieraLPM_Values.h DiagTask.c DiagTask.h DiagValues.c etapF0.c etapF0.h f0_cmd_interface.c f0_cmd_interface.h serialPSOCListener.c serialPSOCListener.h
  group Product/EDID
    ../Product/EDID/: A4VEDID.h EDID_Transfer.c EDID_Transfer.h edidapi.c edidapi.h ediddefs.h edidmodify.c edidmodify.h edidparse.c edidparse.h
  group Product/IPC
    ../Product/IPC/: IpcBulkVariant.c IpcVariant.c
  group Product/Keys
    ../Product/Keys/: KeyVariant.c KeyVariant.h
  group Product/NVRam
    ../Product/NVRam/: GlobalParameterList.c GlobalParameterList.h ProductNvMfg.c ProductNvMfg.h ProductSystemParams.c ProductSystemParams.h
  group Product/Power
    ../Product/Power/: PowerVariant.c
  group Product/SII9437
    ../Product/SII9437/: Sii9437Driver.c Sii9437Driver.h Sii9437Task.c Sii9437Task.h
  group Product/SiliconImage/application/Sil9437/platform_nuc123_coos
    ../Product/SiliconImage/application/SiI9437/platform_nuc123_coos/: sii943x_user_def.h sii_datatypes.h
  group Product/SiliconImage/driver/internal
    ../Product/SiliconImage/driver/internal/: sii_lib_data.h sii_system_api.h
  group Product/SiliconImage/driver/internal/assert
    ../Product/SiliconImage/driver/internal/assert/: sii_sys_assert.c sii_sys_assert_api.h
  group Product/SiliconImage/driver/internal/cra
    ../Product/SiliconImage/driver/internal/cra/: sii_drv_cra.c sii_drv_cra_api.h
  group Product/SiliconImage/driver/internal/log
    ../Product/SiliconImage/driver/internal/log/: sii_sys_log.c sii_sys_log_api.h
  group Product/SiliconImage/driver/internal/malloc
    ../Product/SiliconImage/driver/internal/malloc/: sii_sys_malloc.c sii_sys_malloc_api.h
  group Product/SiliconImage/driver/internal/obj
    ../Product/SiliconImage/driver/internal/obj/: sii_sys_obj.c sii_sys_obj_api.h
  group Product/SiliconImage/driver/internal/pipe
    ../Product/SiliconImage/driver/internal/pipe/: sii_lib_pipe.c sii_lib_pipe_api.h
  group Product/SiliconImage/driver/internal/seq
    ../Product/SiliconImage/driver/internal/seq/: sii_sys_seq.c sii_sys_seq_api.h
  group Product/SiliconImage/driver/internal/time
    ../Product/SiliconImage/driver/internal/time/: sii_sys_time.c sii_sys_time_api.h
  group Product/SiliconImage/driver/sii9437
    ../Product/SiliconImage/driver/sii9437/: sii9437_api.h sii9437_drv.c sii9437_drv.h sii9437_hal.c sii9437_regs.h sii9437_version.h
  group Product/SiliconImage/platform
    ../Product/SiliconImage/platform/: sii_platform_api.h
  group Product/SiliconImage/platform/nuc123_coos
    ../Product/SiliconImage/platform/nuc123_coos/: sii_platform_api.c
  group Product/SourceChange
    ../Product/SourceChange/: sourceInterface.c SourceList.c SourceRecipe.c
  group Product/SystemStates
    ../Product/SystemStates/: SystemStateVariant.c SystemStateVariant.h
  group Product/Tap
    ../Product/Tap/: DiagsDispatcher.c DiagsDispatcher.h etapCEC.c etapCEC.h etapEDID.c etapEDID.h etapHDMI.c etapHDMI.h etapVersion.c etapVersion.h TapCommands.c
  group Product/Tasks
    ../Product/Tasks/: VariantEvents.h VariantTasks.c
  group Product/Timers
    ../Product/Timers/: TimerExampleTask.c TimerExampleTask.h VariantTimers.h
  group Product/UI
    ../Product/UI/: UIHelper.c UIHelper.h
  group Product/Update
    ../Product/Update/: UpdateVariant.c UpdateVariant.h
  group Shared
    ../Shared/: PSoCComms.h RivieraLPM_IpcProtocol.h RivieraLPM_KeyValues.h versionlib.c versionlib.h
