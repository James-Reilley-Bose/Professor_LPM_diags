<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\lpm.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>lpm build all</name>
    </batchDefinition>
  </batchBuild>
</workspace>


