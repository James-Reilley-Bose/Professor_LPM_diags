# IAR project lpm.ewp, settings and files
configuration EXAMPLE (ARM, debug)
  General.OGChipSelectEditMenu: STM32F205VG ST STM32F205VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDiagSuppress: Pa050, Pa039
  ICCARM.IExtraOptions: --enum_is_int; --no_path_in_file_macros
  ICCARM.PreInclude: ..\ExampleProject\Configuration\example_predefine.h
  ICCARM.CCIncludePath2: ..\; ..\Drivers\Bose; ..\Drivers\Bose\Common; ..\Drivers\Bose\External\; ..\Drivers\Bose\External\CC2500; ..\Drivers\Bose\External\SPIFlash; ..\Drivers\Bose\Internal; ..\Drivers\Bose\Internal\ADC; ..\Drivers\Bose\Internal\DMA_Manager; ..\Drivers\Bose\Internal\I2C; ..\Drivers\Bose\Internal\InternalFlash; ..\Drivers\Bose\Internal\IR; ..\Drivers\Bose\Internal\SPI; ..\Drivers\Bose\Internal\UART; ..\Drivers\ST\STM32F1xx\CoreSupport; ..\Drivers\ST\STM32F1xx\DeviceSupport; ..\Drivers\ST\STM32F1xx\DeviceSupport\startup; ..\Drivers\ST\STM32F1xx\STM32F10x_StdPeriph_Driver; ..\Drivers\ST\STM32F1xx\STM32F10x_StdPeriph_Driver\inc; ..\Drivers\ST\STM32F1xx\STM32F10x_StdPeriph_Driver\src; ..\Drivers\ST\STM32F2xx\CoreSupport; ..\Drivers\ST\STM32F2xx\DeviceSupport; ..\Drivers\ST\STM32F2xx\DeviceSupport\iar; ..\Drivers\ST\STM32F2xx\STM32_USB_Device_Library\Class\cdc\inc; ..\Drivers\ST\STM32F2xx\STM32_USB_Device_Library\Core\inc; ..\Drivers\ST\STM32F2xx\STM32_USB_OTG_Driver\inc; ..\Drivers\ST\STM32F2xx\STM32F2xx_StdPeriph_Driver; ..\Drivers\ST\STM32F2xx\STM32F2xx_StdPeriph_Driver\inc; ..\Drivers\ST\STM32F2xx\STM32F2xx_StdPeriph_Driver\src; ..\Drivers\ST\STM32F2xx\USB_VCP_Logger\inc; ..\ExampleProject; ..\ExampleProject\Configuration; ..\ExampleProject\Keys; ..\ExampleProject\Power; ..\ExampleProject\Tap; ..\ExampleProject\Tasks; ..\ExampleProject\Timers; ..\Middleware\Bose\Common; ..\Middleware\Bose\Common\PWMTimer; ..\Middleware\Bose\Configuration; ..\Middleware\Bose\IPC; ..\Middleware\Bose\Keys; ..\Middleware\Bose\Logging; ..\Middleware\Bose\Logging\TBLSerial; ..\Middleware\Bose\NVRam; ..\Middleware\Bose\NVRam\include; ..\Middleware\Bose\NVRam\source; ..\Middleware\Bose\Power; ..\Middleware\Bose\Tap; ..\Middleware\Bose\Tap\Listener; ..\Middleware\Bose\Tap\Parser; ..\Middleware\Bose\Update; ..\Middleware\ThirdParty\Compression\Heatshrink; ..\RTOS\FreeRTOS; ..\RTOS\FreeRTOS\CortexM3_Port; ..\RTOS\FreeRTOS\include; ..\Shared; ..\Tools\VersionLib
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: USING_FREE_RTOS; NEW_INTERRUPT_SCHEME
  AARM.AUserIncludes: ..\Middleware\Bose\Common; ..\ExampleProject\Configuration
  OBJCOPY.OOCOutputFile: lpm.bin
  prebuild: cmd /c "cmd /c "cd .. && perl ..\Tools\VersionLib\gen_version.pl < ..\ExampleProject\Configuration\version.h.in > ..\ExampleProject\Configuration\version.h""
  postbuild: ielftool.exe --ihex "$TARGET_PATH$" "$TARGET_BPATH$.hex"
  ILINK.IlinkOutputFile: lpm.out
  ILINK.IlinkIcfFile: icf\EXAMPLE.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Drivers/Bose/Common
    ../Drivers/Bose/Common/: driverLibCommon.c driverLibCommon.h
  group Drivers/Bose/External/CC2500
    ../Drivers/Bose/External/CC2500/: CC2500_driver.c CC2500_driver.h cc2500_platform.c cc2500_platform.h regs_chipcon.h RFTimer.c RFTimer.h
  group Drivers/Bose/External/SPIFlash
    ../Drivers/Bose/External/SPIFlash/: mmsw_byte_ordering.h mmsw_util.h nvram.c nvram.h nvram_device.c nvram_device.h nvram_platform.c nvram_platform.h nvram_platform_config.h
  group Drivers/Bose/Internal/ADC
    ../Drivers/Bose/Internal/ADC/: adc.c adc.h
  group Drivers/Bose/Internal/DMA
    ../Drivers/Bose/Internal/DMA_Manager/: DmaManager.c DmaManager.h DmaManagerInternal.h
  group Drivers/Bose/Internal/I2C
    ../Drivers/Bose/Internal/I2C/: i2cBusDriver.h i2cMaster_API.c i2cMaster_API.h
  group Drivers/Bose/Internal/InternalFlash
    ../Drivers/Bose/Internal/InternalFlash/: internalFlash.c internalFlash.h internalFlash_STM32F205RE.h internalFlash_STM32F205VG.h internalFlashAPI.c internalFlashAPI.h
  group Drivers/Bose/Internal/IR
    ../Drivers/Bose/Internal/IR/: ir.c ir.h
  group Drivers/Bose/Internal/SPI
    ../Drivers/Bose/Internal/SPI/: SpiBus_API.c SpiBus_API.h SpiBusDriver.h
  group Drivers/Bose/Internal/UART
    ../Drivers/Bose/Internal/UART/: BoseUSART_API.c BoseUSART_API.h
  group Drivers/ST/STM32F2xx/CoreSupport
    ../Drivers/ST/STM32F2xx/CoreSupport/: core_cm3.c core_cm3.h cortexm3_macro.s exception_handle.s
  group Drivers/ST/STM32F2xx/DeviceSupport
    ../Drivers/ST/STM32F2xx/DeviceSupport/: stm32f2xx.h system_stm32f2xx.c system_stm32f2xx.h
  group Drivers/ST/STM32F2xx/DeviceSupport/iar
    ../Drivers/ST/STM32F2xx/DeviceSupport/iar/: stm32f2xx_conf.h stm32f2xx_interrupts.c stm32f2xx_interrupts.h stm32f2xx_vectortable.c
  group Drivers/ST/STM32F2xx/STM32_USB_Device_Library/Class/cdc/src
    ../Drivers/ST/STM32F2xx/STM32_USB_Device_Library/Class/cdc/src/: usbd_cdc_core.c
  group Drivers/ST/STM32F2xx/STM32_USB_Device_Library/Core/src
    ../Drivers/ST/STM32F2xx/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
  group Drivers/ST/STM32F2xx/STM32_USB_OTG_Driver/src
    ../Drivers/ST/STM32F2xx/STM32_USB_OTG_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c
  group Drivers/ST/STM32F2xx/STM32F2xx_StdPeriph_Driver/inc
    ../Drivers/ST/STM32F2xx/STM32F2xx_StdPeriph_Driver/inc/: misc.h stm32f2xx_adc.h stm32f2xx_can.h stm32f2xx_crc.h stm32f2xx_cryp.h stm32f2xx_dac.h stm32f2xx_dbgmcu.h stm32f2xx_dcmi.h stm32f2xx_dma.h stm32f2xx_exti.h stm32f2xx_flash.h stm32f2xx_fsmc.h stm32f2xx_gpio.h stm32f2xx_hash.h stm32f2xx_i2c.h stm32f2xx_ip_dbg.h stm32f2xx_iwdg.h stm32f2xx_pwr.h stm32f2xx_rcc.h stm32f2xx_rng.h stm32f2xx_rtc.h stm32f2xx_sdio.h stm32f2xx_spi.h stm32f2xx_syscfg.h stm32f2xx_tim.h stm32f2xx_usart.h stm32f2xx_wwdg.h
  group Drivers/ST/STM32F2xx/STM32F2xx_StdPeriph_Driver/src
    ../Drivers/ST/STM32F2xx/STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_adc.c stm32f2xx_can.c stm32f2xx_crc.c stm32f2xx_dac.c stm32f2xx_dbgmcu.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_fsmc.c stm32f2xx_gpio.c stm32f2xx_i2c.c stm32f2xx_ip_dbg.c stm32f2xx_iwdg.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_rtc.c stm32f2xx_sdio.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c stm32f2xx_wwdg.c
  group Drivers/ST/STM32F2xx/USB_VCP_Logger/inc
    ../Drivers/ST/STM32F2xx/USB_VCP_Logger/inc/: usb_conf.h usbd_cdc_logger.h usbd_conf.h usbd_desc.h
  group Drivers/ST/STM32F2xx/USB_VCP_Logger/src
    ../Drivers/ST/STM32F2xx/USB_VCP_Logger/src/: usb_bsp.c usbd_cdc_logger.c usbd_desc.c
  group ExampleProject/Configuration
    ../ExampleProject/Configuration/: example_config.c example_ext_flash_map.h example_memory_map.h example_pin_mapping.h example_predefine.h FreeRTOSConfig.h variant_config.h
  group ExampleProject/Keys
    ../ExampleProject/Keys/: KeyTask.c KeyTask.h
  group ExampleProject/Power
    ../ExampleProject/Power/: PowerExample.c
  group ExampleProject/Tap
    ../ExampleProject/Tap/: etapVersion.c etapVersion.h TapCommands.c
  group ExampleProject/Tasks
    ../ExampleProject/Tasks/: VariantEvents.h VariantTasks.c
  group ExampleProject/Timers
    ../ExampleProject/Timers/: TimerExampleTask.c TimerExampleTask.h VariantTimers.h
  group Middleware/Bose/Common
    ../Middleware/Bose/Common/: Assert.h bitband.h boselinkmessages.h buffermanager.c buffermanager.h defs.h EventBlocking.c EventDefinitions.c EventDefinitions.h exception_handle.h genTimer.c genTimer.h gpio_mapping.c gpio_mapping.h HwDefines.h HwMacros.h instrument.c instrument.h interrupt.c interrupt.h LinkedList.c LinkedList.h main.c mpu.c platform_settings.h project.h QueueManager.c QueueManager.h RebootState.h stringbuffer.c stringbuffer.h SystemAnalysis.c SystemAnalysis.h SystemAnalysisDefines.h SystemCoreReboot.c TaskDefs.c TaskDefs.h TaskManager.c TaskManager.h TimerIDs.h TIMx.h unwind.c viewNotify.c viewNotify.h watchdog.c watchdog.h
  group Middleware/Bose/Common/PWMTimer
    ../Middleware/Bose/Common/PWMTimer/: GingerPWMTimerConfig.c MaxwellPWMTimerConfig.c PWMTimer.c PWMTimer.h PWMTimerConfig.h SkipperPWMTimerConfig.c
  group Middleware/Bose/Configuration
    ../Middleware/Bose/Configuration/: configuresystem.h
  group Middleware/Bose/IPC
    ../Middleware/Bose/IPC/: A4V_IpcPlatformConfig.h IPCBulk.c IPCBulk.h IpcDsp.c IpcDsp.h IpcI2CRxTxTask.c IpcI2CRxTxTask.h IpcInterface.c IpcInterface.h IpcKeys.c IpcKeys.h IpcPassThrough.c IpcPassThrough.h IpcProtocolLpm.c IpcProtocolLpm.h IPCRouterTask.c IPCRouterTask.h IpcRx.c IpcRx.h IpcStatus.c IpcStatus.h IpcTest.c IpcTest.h IpcTx.c IpcTx.h IpcTxTask.c IpcTxTask.h
  group Middleware/Bose/Keys
    ../Middleware/Bose/Keys/: ConsoleKeys.c ConsoleKeys.h KeyData.h KeyHandler.c KeyHandler.h KeyHandlerTask.c KeyHandlerTask.h KeyTimings.h KeyValues.c
  group Middleware/Bose/Logging
    ../Middleware/Bose/Logging/: LoggerTask.c LoggerTask.h logimpl.c nvstore.c nvstore.h ringbufferstore.c ringbufferstore.h rottenlog.c rottenlog.h tapstore.c tapstore.h
  group Middleware/Bose/Logging/TBLSerial
    ../Middleware/Bose/Logging/TBLSerial/: TBLSerial.c TBLSerial.h
  group Middleware/Bose/NVRam
    ../Middleware/Bose/NVRam/: globalParameterList.c globalParameterList.h nv.h nv_internal_params.c nv_internal_params.h nv_mfg.c nv_mfg.h nv_mfg_struct.h nv_system.c nv_system.h nv_system_struct.h
  group Middleware/Bose/Power
    ../Middleware/Bose/Power/: PowerTask.c PowerTask.h
  group Middleware/Bose/Tap
    ../Middleware/Bose/Tap/: ascii.h
  group Middleware/Bose/Tap/Listener
    ../Middleware/Bose/Tap/Listener/: serialTapListener.c serialTapListener.h TapListenerAPI.c TapListenerAPI.h
  group Middleware/Bose/Tap/Parser
    ../Middleware/Bose/Tap/Parser/: etap.c etap.h etapAssert.c etapAssert.h etapcoms.c etapcoms.h etapFlash.c etapFlash.h etapGpio.c etapGpio.h etapHeap.c etapHeap.h etapI2C.c etapI2C.h etapInternalFlash.c etapInternalFlash.h etapIpc.c etapIpc.h etapKeys.c etapKeys.h etapLog.c etapLog.h etapNV.c etapNV.h etapPassthrough.c etapPassthrough.h etapPower.c etapPower.h etapSpi.c etapSpi.h etapTasks.c etapTasks.h etapUpdate.c etapUpdate.h SystemEventsTAP.c SystemEventsTAP.h TAP_API.h TapParserAPI.c TapParserAPI.h
  group Middleware/Bose/Update
    ../Middleware/Bose/Update/: UpdateManagerBlob.c UpdateManagerBlob.h UpdateManagerStateDefinitions.c UpdateManagerStateDefinitions.h UpdateManagerTask.c UpdateManagerTask.h UpdateModuleBase.c UpdateModuleBase.h UpdateModuleDsp.c UpdateModuleDsp.h UpdateModuleF0.c UpdateModuleF0.h UpdateModuleHDMI.c UpdateModuleHDMI.h UpdateModuleMicro.c UpdateModuleMicro.h UpdateModuleRadio.c UpdateModuleRadio.h UpdateModuleRemote.c UpdateModuleRemote.h UpdateModuleSM2Authenticate.c UpdateModuleSM2Authenticate.h UpdateModuleSM2Downloading.c UpdateModuleSM2Downloading.h UpdateModuleSM2WaitDownload.c UpdateModuleSM2WaitDownload.h UpdateModuleSM2WaitExtPeriph.c UpdateModuleSM2WaitExtPeriph.h UpdateModuleSM2WaitInstall.c UpdateModuleSM2WaitInstall.h UpdateModuleSpeakers.c UpdateModuleSpeakers.h
  group Middleware/ThirdParty/heatshrink-0.4.1
    ../Middleware/ThirdParty/heatshrink-0.4.1/: heatshrink_common.h heatshrink_config.h heatshrink_decoder.c heatshrink_decoder.h heatshrink_encoder.h
  group RTOS/FreeRTOS
    ../RTOS/FreeRTOS/: croutine.c event_groups.c heap_1.c heap_2.c heap_3.c heap_4.c heap_5.c list.c queue.c tasks.c timers.c
  group RTOS/FreeRTOS/CortexM3_Port
    ../RTOS/FreeRTOS/CortexM3_Port/: port.c portasm.s portmacro.h
  group RTOS/FreeRTOS/include
    ../RTOS/FreeRTOS/include/: croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h
  group Shared
    ../Shared/: A4V_IpcProtocol.h A4V_KeyValues.h
  group Tools/VersionLib
    ../Tools/VersionLib/: versionlib.c versionlib.h
